# Keil uVision project UartDMA.uvprojx, settings and files
target stm32f051xx (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F072R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: UartDMA
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX
  c include: ..\..\..\lib\STM32F0xx_StdPeriph_Driver\inc;..\..\..\lib\CMSIS\Include;..\..\..\lib\CMSIS\ST\STM32F0xx\Include;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../src/: main.c stm32f0xx_conf.h
  group STDPeripheralLibrary
    ../../../lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_usart.c stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_wwdg.c
  group documents
    ./: readme.txt
software components: CMSIS:CORE 4.2.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.5.0
