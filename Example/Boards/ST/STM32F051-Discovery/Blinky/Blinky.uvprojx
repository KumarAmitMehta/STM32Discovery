# Keil uVision project Blinky.uvprojx, settings and files
target STM32F051 Flash (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target STM32F051 RAM (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x1000
software components: CMSIS:CORE 3.40.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.5.0
